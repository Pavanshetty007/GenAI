Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Infra-Plumbing.ifc
Time: 2025-02-27T11:09:14
Written by: IFC-manager for SketchUp (5.3.3)
Made in: SketchUp 2024 (24.0.594)

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (6)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
road parking - site | A designated parking area, providing space for vehicles.
road river bridge - site | The site of the road river bridge, connecting different areas.
rail river bridge - site | The site of the rail river bridge, facilitating train crossings.
road rail bridge - site | The site of the road rail bridge, supporting both road and rail traffic.
road - site | A designated parking area, providing space for vehicles.

# IfcBuilding: arched (2)
Description: A strong rail bridge, supporting trains as they cross over.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuilding: girder, road river bridge
Description: A sturdy bridge, spanning the river and connecting roads.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcDistributionSystem, road wastewater system
Description: A comprehensive wastewater system, ensuring efficient sewage management.; PredefinedType: SEWAGE

# IfcElementAssembly: highway location marker (2)
In: road rail bridge - site
Type - Description: A marker indicating specific locations along the highway.; ElementType: signalassembly; PredefinedType: USERDEFINED
AssemblyPlace: SITE

# IfcElementAssembly: sewer manhole (2)
In: road river bridge - site
Type - Description: A manhole, providing access to the sewer system.; ElementType: accessory_assembly; PredefinedType: ACCESSORY_ASSEMBLY
AssemblyPlace: SITE; Group: road wastewater system

# IfcPipeSegment: sewer pipe (24)
Type - Description: A sturdy sewer pipe, ensuring efficient waste management.; ElementType: culvert; PredefinedType: CULVERT
Material: concrete_reinforced_prefab; Group: road wastewater system
Name | In
8 x sewer pipe | road parking - site
8 x sewer pipe | road rail bridge - site
8 x sewer pipe | road - site
