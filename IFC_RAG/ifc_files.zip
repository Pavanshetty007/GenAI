Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Building-Landscaping.ifc
Time: 2024-11-14T11:09:12
Written by: IFC-manager for SketchUp (5.3.3)
Made in: SketchUp 2024 (24.0.594)

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (2)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
house - site | Smoke curls from a friendly chimney, promising warmth within this idyllic hilltop house.

# IfcBuildingElementProxy, Group#17
In: house - site
Material: Default

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcBuildingElementProxy: origin
In: house - site
Type - Description: The local position for coordination of aspect models.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_white

# IfcGeographicElement: house - site - grass
In: house - site
Type - Description: A lush grassland, a green carpet that stretches to the horizon.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: house - site - soil
In: house - site
Type - Description: Rich, fertile topsoil, the foundation of thriving landscapes.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: house - site - underground
In: house - site
Type - Description: Layers of subsurface strata, holding the secrets of the earth.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_soil_generic

# IfcGeographicElement: tree
In: house - site
Type - Description: A fruitful apple tree, providing delicious apples, nature's candy store.; ElementType: vegetation; PredefinedType: USERDEFINED
Classification: L-TRA Tree (CCI Construction); Material: vegetation_generic
