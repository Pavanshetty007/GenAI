Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Infra-Rail.ifc
Time: 2024-11-14T11:09:14
Written by: IFC-manager for SketchUp (5.3.3)
Made in: SketchUp 2024 (24.0.594)

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (6)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
road parking - site | A designated parking area, providing space for vehicles.
road river bridge - site | The site of the road river bridge, connecting different areas.
rail river bridge - site | The site of the rail river bridge, facilitating train crossings.
road rail bridge - site | The site of the road rail bridge, supporting both road and rail traffic.
road - site | A designated parking area, providing space for vehicles.

# IfcBuilding: track (2)
Description: Durable rail tracks, guiding trains safely along their path.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey: track (2)
In: Rail track
Description: Durable rail tracks, guiding trains safely along their path.; Elevation: 7774.58 mm; Classification: A-FDA Rail track (CCI Construction)

# IfcBuildingElementProxy: ballastbed (2)
In: Rail track
Type - Description: A sturdy ballast bed, providing a stable base for railway tracks.; ElementType: ballastbed; PredefinedType: USERDEFINED
Material: bulk-material_ballast_generic

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcBuildingElementProxy: rail (4)
In: Rail track
Type - Description: Strong rails, guiding trains safely along their path.; ElementType: rail; PredefinedType: USERDEFINED
Material: metal_hot-rolled-steel

# IfcBuildingElementProxy: sleeper wood (66)
In: Rail track
Type - Description: Durable wooden sleepers, supporting the railway tracks.; ElementType: sleeper; PredefinedType: USERDEFINED
Material: wood-generic

# IfcElementAssembly: highway location marker (2)
In: road rail bridge - site
Type - Description: A marker indicating specific locations along the highway.; ElementType: signalassembly; PredefinedType: USERDEFINED
AssemblyPlace: SITE
