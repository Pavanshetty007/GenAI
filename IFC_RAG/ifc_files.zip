Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Infra-Landscaping.ifc
Time: 2024-11-14T11:09:13
Written by: IFC-manager for SketchUp (5.3.3)
Made in: SketchUp 2024 (24.0.594)

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (8)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
park - site | A sample scene meadow, showcasing an orchard.
road parking - site | A designated parking area, providing space for vehicles.
road river bridge - site | The site of the road river bridge, connecting different areas.
rail river bridge - site | The site of the rail river bridge, facilitating train crossings.
road rail bridge - site | The site of the road rail bridge, supporting both road and rail traffic.
meadow - site | A boundless expanse of lush green, a feast for the eyes and a yearning in the hearts of grazing cows.
road - site | A designated parking area, providing space for vehicles.

# IfcBuilding (5)
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm; Classification: E-CAE Road (CCI Construction)
Name | Description
road parking - road | A well-constructed road, connecting various parts of the infrastructure.
2 x bridge road connection | A connection point, linking the bridge road to other infrastructure.
2 x road | A well-constructed road, connecting various parts of the infrastructure.

# IfcBuilding: arched (2)
Description: A strong rail bridge, supporting trains as they cross over.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuilding: girder, road river bridge
Description: A sturdy bridge, spanning the river and connecting roads.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuilding: track (2)
Description: Durable rail tracks, guiding trains safely along their path.; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy (5)
Name | In | Material
underground - road | road parking - site | bulk-material_soil_generic
Group#16 | road river bridge - site | Default
underground - river | rail river bridge - site | bulk-material_soil_generic
underground - road | road rail bridge - site | bulk-material_soil_generic
underground - road | road - site | bulk-material_soil_generic

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcBuildingElementProxy: highway location marker - sign (10)
Type - Description: A sign indicating specific locations along the highway.; ElementType: pictoral; PredefinedType: ELEMENT
Material: metal_aluminum_sheet_coated-green
Name | In
4 x highway location marker - sign | road parking - site
2 x highway location marker - sign | road rail bridge - site
4 x highway location marker - sign | road - site

# IfcElementAssembly: highway location marker (10)
Type - Description: A marker indicating specific locations along the highway.; ElementType: signalassembly; PredefinedType: USERDEFINED
AssemblyPlace: SITE
Name | In
4 x highway location marker | road parking - site
2 x highway location marker | road rail bridge - site
4 x highway location marker | road - site

# IfcGeographicElement: apple (48)
In: park - site
Type - Description: A ripe apple, ready for picking.; ElementType: vegetation; PredefinedType: USERDEFINED
Classification: apple Apple (Fruit and vegetables); Material: vegetation_apple
SizeSet - Volume: 0.762 mm; Height: 3378.2 mm
Name
42 x apple
6 x Apple

# IfcGeographicElement: apple tree (6)
In: park - site
Type - Description: A fruitful apple tree, providing delicious apples.; ElementType: vegetation; PredefinedType: USERDEFINED
Classification: L-TRA Tree (CCI Construction); Material: vegetation_generic

# IfcGeographicElement: generic - site - underground
In: meadow - site
Type - Description: Layers of subsurface strata, holding the earth's best-kept secrets, like a geological treasure chest.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_soil_generic

# IfcGeographicElement: grass - site - grass
In: meadow - site
Type - Description: A lush grassland, a green carpet that stretches to the horizon, perfect for a spontaneous picnic or a cow's daydream.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: grass - site - soil
In: meadow - site
Type - Description: Rich, fertile topsoil, the foundation of thriving landscapes.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: park - site - grass
In: park - site
Type - Description: A lush grassland, a green carpet that stretches to the horizon, perfect for a spontaneous picnic or a cow's daydream.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: park - site - soil
In: park - site
Type - Description: Rich, fertile topsoil, the foundation of thriving landscapes.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: park - site - underground
In: park - site
Type - Description: Layers of subsurface strata, holding the earth's best-kept secrets, like a geological treasure chest.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_soil_generic

# IfcGeographicElement: river bed (2)
Type - Description: The river bed, a natural channel carved by flowing water, home to pebbles and the occasional treasure; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_sand_generic
Name | In
river bed | road river bridge - site
river bed | rail river bridge - site

# IfcGeographicElement: river stream (2)
Type - Description: A flowing river stream, shaping the landscape as it moves, teeming with fish and plants.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_water_surfacewater
Name | In
river stream | road river bridge - site
river stream | rail river bridge - site

# IfcGeographicElement: riverside - grass
In: rail river bridge - site
Type - Description: More lush vegetation, adding to the greenery along the roadside verge.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: riverside - soil
In: rail river bridge - site
Type - Description: A fertile layer of soil, rich in nutrients, nourishes the lush grass that lines the river's edge.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: road - roadside verge - grass (2)
Type - Description: Green grass, covering the roadside verge with a lush layer.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass
Name | In
road - roadside verge - grass | road rail bridge - site
road - roadside verge - grass | road - site

# IfcGeographicElement: road - roadside verge - soil (2)
Type - Description: Fertile soil, forming the base of the roadside verge.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic
Name | In
road - roadside verge - soil | road rail bridge - site
road - roadside verge - soil | road - site

# IfcGeographicElement: road parking - roadside verge - grass
In: road parking - site
Type - Description: Green grass, covering the roadside verge with a lush layer.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: road parking - roadside verge - soil
In: road parking - site
Type - Description: Fertile soil, forming the base of the roadside verge.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: road river bridge - grass
In: road river bridge - site
Type - Description: Lush grass, enhancing the landscape around the road river bridge.; ElementType: vegetation; PredefinedType: USERDEFINED
Material: vegetation_grass

# IfcGeographicElement: road river bridge - soil
In: road river bridge - site
Type - Description: Fertile soil, supporting the structure of the road river bridge.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_topsoil_generic

# IfcGeographicElement: road river bridge - underground
In: road river bridge - site
Type - Description: The underground layers, supporting the road river bridge above.; ElementType: terrain; PredefinedType: TERRAIN
Material: bulk-material_soil_generic

# IfcGeographicElement: tree
In: road river bridge - site
Type - Description: A fruitful apple tree, providing delicious apples, nature's candy store.; ElementType: vegetation; PredefinedType: USERDEFINED
Classification: L-TRA Tree (CCI Construction); Material: vegetation_generic

# IfcMember: highway location marker - post (10)
Type - Description: A post supporting the highway location marker.; ElementType: post; PredefinedType: POST
Material: metal_steel-galvanized
Pset_MemberCommon - IsExternal: yes; LoadBearing: no
Name | In
4 x highway location marker - post | road parking - site
2 x highway location marker - post | road rail bridge - site
4 x highway location marker - post | road - site
