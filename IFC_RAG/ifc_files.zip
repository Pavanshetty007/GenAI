Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: Building-Hvac.ifc
Time: 2024-11-14T11:09:12
Written by: IFC-manager for SketchUp (5.3.3)
Made in: SketchUp 2024 (24.0.594)

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (2)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
house - site | Smoke curls from a friendly chimney, promising warmth within this idyllic hilltop house.

# IfcBuilding, Single-family house
Description: The main building structure, providing shelter and space.; LongName: house - building; Classification: E-AAA Single-family house (CCI Construction)
Pset_BuildingCommon - ConstructionMethod: new construction

# IfcBuildingStorey, 00 groundfloor
In: Single-family house
Description: The ground floor, forming the base level of the building.; Elevation: -1.80478e-12 mm

# IfcAirTerminal: chimney cover
In: 00 groundfloor
Type - Description: A sturdy cover, protecting the chimney from the elements.; ElementType: chimney cover; PredefinedType: USERDEFINED
Material: metal_steel_generic_coated-anthracitegrey; Group: house - chimney flue

# IfcAirTerminal: house fireplace cap
In: 00 groundfloor
Type - Description: A hidden concrete cap, secretly keeping the fireplace safe and sound.; ElementType: fireplace cap; PredefinedType: USERDEFINED
Material: concrete_reinforced_prefab; Group: house - chimney flue

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcBuildingElementProxy: origin
In: house - site
Type - Description: The local position for coordination of aspect models.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_white

# IfcChimney: house - chimney
In: 00 groundfloor
Type - Description: A chimney, standing tall and proud, guiding smoke away from the home.; ElementType: flue; PredefinedType: USERDEFINED
Material: stone_sand-lime

# IfcDistributionSystem: exhaust, house - chimney flue
Description: A vital passage, guiding smoke safely out of the home.; PredefinedType: EXHAUST

# IfcDuctSegment: building element
In: 00 groundfloor
Type - ElementType: rigidsegment; PredefinedType: RIGIDSEGMENT
Material: metal_steel-galvanized; Group: house - chimney flue
